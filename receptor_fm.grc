<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receptor_fm</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receptor FM</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cut_freq</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>106000000</value></param>
<param><key>label</key><value>frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trans_width</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>comment</key><value>Opcional, para adaptar automáticamente o volume</value></param>
<param><key>decay_rate</key><value>6.25e-4</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0_1</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>quad_rate</key><value>480e3</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_filter_ch0</key><value>1</value></param>
<param><key>cmix_mode_ch0</key><value>1</value></param>
<param><key>calibration_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0.1e6</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>60</value></param>
<param><key>lna_path_ch0</key><value>2</value></param>
<param><key>lna_path_mini</key><value>3</value></param>
<param><key>analog_bandw_ch1</key><value>2e6</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibration_ch1</key><value>1</value></param>
<param><key>digital_bandw_ch1</key><value>100e3</value></param>
<param><key>digital_filter_ch1</key><value>1</value></param>
<param><key>gain_dB_ch1</key><value>60</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>device_type</key><value>1</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>frequency</value></param>
<param><key>samp_rate</key><value>2e6</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>cutoff_freq</key><value>cut_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>2e6</value></param>
<param><key>width</key><value>trans_width</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate*48/200</value></param>
<param><key>fc</key><value>frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0_1</value></param>
<param><key>comment</key><value>Conversión de 2 MHz a 480 kHz</value></param>
<param><key>decim</key><value>200</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0_1</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0_0</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>rational_resampler_xxx_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_1</source_block_id><sink_block_id>analog_wfm_rcv_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
